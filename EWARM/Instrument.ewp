# IAR project Instrument.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: YTM32B1MC03 YTM32B1MC03
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.CCDefines: YTM32B1MC0; CPU_YTM32B1MC0
  ICCARM.CCIncludePath2: ../board; ../platform/drivers/src/clock/YTM32B1Mx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/spi; ../platform/drivers/src/flexcan; ../platform/drivers/src/ptmr; ../platform/drivers/src/adc; ../platform/drivers/src/uart; ../platform/drivers/inc; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1MC0/include; ../platform/devices/YTM32B1MC0/startup; ../CMSIS/Core/Include; ../rtos/osif; ../middleware/utility_flash_ecc_fault; ../middleware/utility_print/printf; ..\board\sc5037; ..\app\common; ..\app\common\config; ..\app\system; ..\app\power; ..\app\ui; ..\app\gauges; ..\app\scheduler; ..; ..\hal; ../platform/drivers/src/lptmr; ..\serve\can; ..\serve\input; ..\serve\nvm; ../platform/drivers/src/flash; ../platform/drivers/src/mpwm; ..\serve\soc; ../platform/drivers/src/i2c; ../platform/drivers/src/power/YTM32B1Mx; ..\serve\diag
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../board; ../platform/drivers/src/clock/YTM32B1Mx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/spi; ../platform/drivers/src/flexcan; ../platform/drivers/src/ptmr; ../platform/drivers/src/adc; ../platform/drivers/src/uart; ../platform/drivers/inc; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1MC0/include; ../platform/devices/YTM32B1MC0/startup; ../CMSIS/Core/Include; ../rtos/osif; ../middleware/utility_flash_ecc_fault; ../middleware/utility_print/printf; ../platform/drivers/src/lptmr; ../platform/drivers/src/flash; ../platform/drivers/src/mpwm; ../platform/drivers/src/i2c; ../platform/drivers/src/power/YTM32B1Mx
  OBJCOPY.OOCOutputFile: Instrument.hex
  ILINK.IlinkOutputFile: Instrument.out
  ILINK.IlinkIcfFile: ../board/yt_linker.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app
    ../app/: main.c
  group app/common
    ../app/common/: cluster_context.h types.h
  group app/common/config
    ../app/common/config/: cfg_buzzer.h cfg_can.h cfg_gauges.h cfg_lcd_addr.h cfg_meter_map.h cfg_power.h cfg_selfcheck.h
  group app/gauges
    ../app/gauges/: ambient.c ambient.h cng.c cng.h coolant.c coolant.h fuel.c fuel.h meter_display.c meter_display.h odo.c odo.h rpm.c rpm.h speed.c speed.h tpms_data.c tpms_data.h
  group app/power
    ../app/power/: lowpower.c lowpower.h pwr_mgr.c pwr_mgr.h voltage.c voltage.h
  group app/sheduler
    ../app/scheduler/: scheduler.c scheduler.h
  group app/system
    ../app/system/: sys_mgr.c sys_mgr.h
  group app/ui
    ../app/ui/: backlight.c backlight.h buzzer.c buzzer.h lcd_ui.c lcd_ui.h led_ind.c led_ind.h
  group board
    ../board/: adc_config.c adc_config.h can_config.c can_config.h clock_config.c clock_config.h dma_config.c dma_config.h flash_config.c flash_config.h i2c_config.c i2c_config.h interrupt_config.c interrupt_config.h lptmr_config.c lptmr_config.h mpwm_config.c mpwm_config.h pin_mux.c pin_mux.h power_config.c power_config.h RamInit0.S RamInit1.c RamInit2.c sdk_project_config.h spi_config.c spi_config.h startup.S uart_config.c uart_config.h utility_flash_ecc_fault_config.c utility_flash_ecc_fault_config.h utility_print_config.c utility_print_config.h vector.S vector_table_copy.c yt_linker.icf
  group board/sc5037
    ../board/sc5037/: sc5037.c sc5037.h sc5037_hal_stm32.c
  group CMSIS/Core/Include
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group hal
    ../hal/: hal_adc.c hal_adc.h hal_backlight.c hal_backlight.h hal_buzzer.c hal_buzzer.h hal_can.c hal_can.h hal_eeprom_bl24c08f.c hal_eeprom_bl24c08f.h hal_gpio.c hal_gpio.h hal_lcd.c hal_lcd.h hal_lowpower.c hal_lowpower.h hal_nvm.c hal_nvm.h hal_rtc_ds1307.c hal_rtc_ds1307.h hal_tick.c hal_tick.h
  group middleware/utility_flash_ecc_fault
    ../middleware/utility_flash_ecc_fault/: flash_ecc_fault.c flash_ecc_fault.h
  group middleware/utility_print/printf
    ../middleware/utility_print/printf/: printf.c printf.h
  group platform/devices
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
  group platform/devices/common
    ../platform/devices/common/: core_common.h
  group platform/devices/YTM32B1MC0/include
    ../platform/devices/YTM32B1MC0/include/: YTM32B1MC0.h YTM32B1MC0_features.h
  group platform/devices/YTM32B1MC0/startup
    ../platform/devices/YTM32B1MC0/startup/: system_YTM32B1MC0.c system_YTM32B1MC0.h
  group platform/drivers/inc
    ../platform/drivers/inc/: adc_driver.h clock.h clock_manager.h dma_driver.h flash_driver.h flexcan_driver.h i2c_driver.h interrupt_manager.h lptmr_driver.h mpwm_common.h mpwm_pwm_driver.h pins_driver.h power_manager.h spi_master_driver.h spi_shared_function.h spi_slave_driver.h uart_driver.h
  group platform/drivers/src/adc
    ../platform/drivers/src/adc/: adc_driver.c adc_hw_access.h
  group platform/drivers/src/adc/doxygen
    ../platform/drivers/src/adc/doxygen/: adc_driver.dox
  group platform/drivers/src/clock/YTM32B1Mx
    ../platform/drivers/src/clock/YTM32B1Mx/: cfmu_hw_access.h clock_YTM32B1Mx.c clock_YTM32B1Mx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
  group platform/drivers/src/clock/YTM32B1Mx/doxygen
    ../platform/drivers/src/clock/YTM32B1Mx/doxygen/: clock_YTM32B1Mx.dox
  group platform/drivers/src/dma
    ../platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
  group platform/drivers/src/dma/doxygen
    ../platform/drivers/src/dma/doxygen/: dma_driver.dox
  group platform/drivers/src/flash
    ../platform/drivers/src/flash/: flash_driver.c flash_hw_access.h
  group platform/drivers/src/flash/doxygen
    ../platform/drivers/src/flash/doxygen/: flash_driver.dox
  group platform/drivers/src/flexcan
    ../platform/drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_hw_access.h flexcan_irq.c flexcan_irq.h
  group platform/drivers/src/flexcan/doxygen
    ../platform/drivers/src/flexcan/doxygen/: flexcan_driver.dox
  group platform/drivers/src/i2c
    ../platform/drivers/src/i2c/: i2c_driver.c i2c_hw_access.h i2c_irq.c i2c_irq.h
  group platform/drivers/src/i2c/doxygen
    ../platform/drivers/src/i2c/doxygen/: i2c.dox i2c_driver.dox
  group platform/drivers/src/interrupt
    ../platform/drivers/src/interrupt/: interrupt_manager.c
  group platform/drivers/src/interrupt/doxygen
    ../platform/drivers/src/interrupt/doxygen/: interrupt.dox
  group platform/drivers/src/lptmr
    ../platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c lptmr_hw_access.h
  group platform/drivers/src/lptmr/doxygen
    ../platform/drivers/src/lptmr/doxygen/: lptmr.dox lptmr_driver.dox
  group platform/drivers/src/mpwm
    ../platform/drivers/src/mpwm/: mpwm_common.c mpwm_hw_access.h mpwm_pwm_driver.c
  group platform/drivers/src/pins
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group platform/drivers/src/pins/doxygen
    ../platform/drivers/src/pins/doxygen/: pins.dox
  group platform/drivers/src/power
    ../platform/drivers/src/power/: power_manager.c
  group platform/drivers/src/power/YTM32B1Mx
    ../platform/drivers/src/power/YTM32B1Mx/: power_manager_YTM32B1Mx.c power_manager_YTM32B1Mx.h
  group platform/drivers/src/spi
    ../platform/drivers/src/spi/: spi_hw_access.c spi_hw_access.h spi_irq.c spi_master_driver.c spi_shared_function.c spi_slave_driver.c
  group platform/drivers/src/spi/doxygen
    ../platform/drivers/src/spi/doxygen/: spi.dox
  group platform/drivers/src/uart
    ../platform/drivers/src/uart/: uart_driver.c uart_hw_access.c uart_hw_access.h uart_irq.c uart_irq.h
  group rtos/osif
    ../rtos/osif/: osif.h osif_baremetal.c
  group serve/can
    ../serve/can/: can_app.c can_app.h can_rx_parse.c can_rx_parse.h can_tx_build.c can_tx_build.h
  group serve/diag
    ../serve/diag/: app_info.c boot_app_if.h boot_shared.c uds_cfg.h uds_did.c uds_did.h uds_svc.c uds_svc.h uds_tp.c uds_tp.h
  group serve/input
    ../serve/input/: hw_input.c hw_input.h radio_input.c radio_input.h rtc_input.c rtc_input.h
  group serve/nvm
    ../serve/nvm/: nvm_storage.c nvm_storage.h odo_log.c odo_log.h
  group serve/soc
    ../serve/soc/: soc_uart.c soc_uart.h
